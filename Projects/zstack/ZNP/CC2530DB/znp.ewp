# IAR project znp.ewp, settings and files
configuration CC2530ZNP (8051, debug)
  General.DerivativeDescriptionFile: $TOOLKIT_DIR$\config\derivatives\Chipcon\CC2530.i51
  ICC8051.CCDefines: HAL_UART_DMA_RX_MAX=255; HAL_UART_DMA_TX_MAX=255; MAXMEMHEAP=2600; ASSERT_RESET
  ICC8051.CCDiagSuppress: Pe001,Pa010
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCIncludePath2: $PROJ_DIR$; ..\Source; ..\..\SE\Source; ..\..\ZMAIN\TI2530ZNP; ..\..\..\..\COMPONENTS\MT; ..\..\..\..\COMPONENTS\HAL\INCLUDE; ..\..\..\..\COMPONENTS\HAL\TARGET\CC2530ZNP; ..\..\..\..\COMPONENTS\OSAL\MCU\CCSOC; ..\..\..\..\COMPONENTS\OSAL\INCLUDE; ..\..\..\..\COMPONENTS\STACK\AF; ..\..\..\..\COMPONENTS\STACK\NWK; ..\..\..\..\COMPONENTS\STACK\SEC; ..\..\..\..\COMPONENTS\STACK\SAPI; ..\..\..\..\COMPONENTS\STACK\SYS; ..\..\..\..\COMPONENTS\STACK\ZCL; ..\..\..\..\COMPONENTS\STACK\ZDO; ..\..\..\..\COMPONENTS\ZMAC\F8W; ..\..\..\..\COMPONENTS\ZMAC; ..\..\..\..\COMPONENTS\SERVICES\SADDR; ..\..\..\..\COMPONENTS\SERVICES\SDATA; ..\..\..\..\COMPONENTS\MAC\INCLUDE; ..\..\..\..\COMPONENTS\MAC\HIGH_LEVEL; ..\..\..\..\COMPONENTS\MAC\LOW_LEVEL\srf04; ..\..\..\..\COMPONENTS\MAC\LOW_LEVEL\srf04\SINGLE_CHIP
  ICC8051.CCStdIncludePath: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\CLIB\
  ICC8051.CCOptLevel: 3
  ICC8051.CCOptStrategy: 1
  XLINK.XclFile: ..\..\Tools\CC2530DB\f8w2530.xcl
configuration CC2531ZNP (8051, debug)
  as the first configuration, except:
  ICC8051.CCDefines: CC2531ZNP; MAXMEMHEAP=3200; ASSERT_RESET
  ICC8051.CCIncludePath2: $PROJ_DIR$; ..\Source; ..\..\SE\Source; ..\..\ZMAIN\TI2530ZNP; ..\..\..\..\COMPONENTS\MT; ..\..\..\..\COMPONENTS\HAL\INCLUDE; ..\..\..\..\COMPONENTS\HAL\TARGET\CC2530USB; ..\..\..\..\COMPONENTS\HAL\TARGET\CC2530USB\usb\library; ..\..\..\..\COMPONENTS\HAL\TARGET\CC2530USB\usb\library\cc2531; ..\..\..\..\COMPONENTS\HAL\TARGET\CC2530USB\usb\class_cdc; ..\..\..\..\COMPONENTS\OSAL\MCU\CCSOC; ..\..\..\..\COMPONENTS\OSAL\INCLUDE; ..\..\..\..\COMPONENTS\STACK\AF; ..\..\..\..\COMPONENTS\STACK\NWK; ..\..\..\..\COMPONENTS\STACK\SEC; ..\..\..\..\COMPONENTS\STACK\SAPI; ..\..\..\..\COMPONENTS\STACK\SYS; ..\..\..\..\COMPONENTS\STACK\ZCL; ..\..\..\..\COMPONENTS\STACK\ZDO; ..\..\..\..\COMPONENTS\ZMAC\F8W; ..\..\..\..\COMPONENTS\ZMAC; ..\..\..\..\COMPONENTS\SERVICES\SADDR; ..\..\..\..\COMPONENTS\SERVICES\SDATA; ..\..\..\..\COMPONENTS\MAC\INCLUDE; ..\..\..\..\COMPONENTS\MAC\HIGH_LEVEL; ..\..\..\..\COMPONENTS\MAC\LOW_LEVEL\srf04; ..\..\..\..\COMPONENTS\MAC\LOW_LEVEL\srf04\SINGLE_CHIP
  group App
    ../Source/: OSAL_ZNP.c znp_app.c znp_app.h znp_spi.c znp_spi.h
  group HAL/Common
    ../../../../Components/hal/common/: hal_assert.c hal_drivers.c
  group HAL/Include
    ../../../../Components/hal/include/: hal_adc.h hal_assert.h hal_board.h hal_ccm.h hal_defs.h hal_drivers.h hal_key.h hal_lcd.h hal_led.h hal_sleep.h hal_timer.h hal_uart.h
    ../../../../COMPONENTS/hal/include/: hal_flash.h
  group HAL/Target/CC2530ZNP/Config
    ../../../../Components/hal/target/CC2530ZNP/: hal_board_cfg.h
  group HAL/Target/CC2530ZNP/Drivers
    ../../../../Components/hal/target/CC2530ZNP/: hal_adc.c hal_dma.c hal_flash.c hal_key.c hal_lcd.c hal_led.c hal_sleep.c hal_spi.c hal_startup.c hal_timer.c hal_uart.c
  group HAL/Target/CC2530ZNP/Includes
    ../../../../Components/hal/target/CC2530ZNP/: hal_aes.h hal_mcu.h hal_spi.h hal_types.h
    ../../../../COMPONENTS/hal/target/CC2530ZNP/: hal_dma.h
  group HAL/Target/CC2531ZNP/Config
    ../../../../Components/hal/target/CC2530USB/: hal_board_cfg.h
  group HAL/Target/CC2531ZNP/Drivers
    ../../../../Components/hal/target/CC2530USB/: hal_adc.c hal_dma.c hal_flash.c hal_key.c hal_lcd.c hal_led.c hal_sleep.c hal_startup.c hal_timer.c hal_uart.c
  group HAL/Target/CC2531ZNP/Includes
    ../../../../Components/hal/target/CC2530USB/: hal_aes.h hal_dma.h hal_mcu.h hal_types.h
  group HAL/Target/CC2531ZNP/USB/class_cdc
    ../../../../Components/hal/target/CC2530USB/usb/class_cdc/: usb_cdc.h usb_cdc_descriptor.s51 usb_cdc_hooks.c usb_cdc_hooks.h usb_firmware_library_config.c usb_firmware_library_config.h usb_firmware_library_headers.h
  group HAL/Target/CC2531ZNP/USB/library
    ../../../../Components/hal/target/CC2530USB/usb/library/: usb_descriptor.h usb_descriptor_parser.c usb_descriptor_parser.h usb_framework.c usb_framework.h usb_framework_structs.h usb_interrupt.h usb_reg.h usb_standard_requests.c usb_standard_requests.h usb_suspend.h
  group HAL/Target/CC2531ZNP/USB/library/cc2531
    ../../../../Components/hal/target/CC2530USB/usb/library/cc2531/: usb_board_cfg.h usb_interrupt.c usb_suspend.c
  group MAC/High Level
    ../../../../Components/mac/high_level/: mac_cfg.c mac_high_level.h mac_pib.h mac_spec.h
  group MAC/Include
    ../../../../Components/mac/include/: mac_api.h
  group MAC/Low Level/Common
    ../../../../Components/mac/low_level/srf04/: mac_assert.h mac_autopend.c mac_autopend.h mac_backoff_timer.c mac_backoff_timer.h mac_low_level.c mac_low_level.h mac_radio.c mac_radio.h mac_rx.c mac_rx.h mac_rx_onoff.c mac_rx_onoff.h mac_sleep.c mac_sleep.h mac_tx.c mac_tx.h
  group MAC/Low Level/System
    ../../../../Components/mac/low_level/srf04/single_chip/: mac_csp_tx.c mac_csp_tx.h mac_mcu.c mac_mcu.h mac_mem.c mac_mem.h mac_radio_defs.c mac_radio_defs.h mac_rffrontend.c
  group MT
    ../../../../Components/mt/: DebugTrace.c DebugTrace.h MT.c MT.h MT_AF.c MT_AF.h MT_APP.c MT_APP.h MT_DEBUG.c MT_DEBUG.h MT_NWK.c MT_NWK.h MT_RPC.h MT_SAPI.c MT_SAPI.h MT_SYS.c MT_SYS.h MT_TASK.c MT_TASK.h MT_UART.c MT_UART.h MT_UTIL.c MT_UTIL.h MT_VERSION.c MT_VERSION.h MT_ZDO.c MT_ZDO.h
  group NWK
    ../../../../Components/stack/nwk/: AddrMgr.h APS.h aps_frag.h aps_groups.h aps_util.h APSMEDE.h AssocList.h BindingTable.h NLMEDE.h nwk.h nwk_bufs.h nwk_globals.c nwk_globals.h nwk_util.h reflecttrack.h rtg.h stub_aps.c
    ../../../../COMPONENTS/stack/nwk/: stub_aps.h
    ../../../../Components/stack/sys/: ZGlobals.c ZGlobals.h
  group OSAL
    ../../../../Components/osal/include/: comdef.h OSAL.h OSAL_Clock.h OSAL_Memory.h OSAL_Nv.h OSAL_PwrMgr.h OSAL_Tasks.h OSAL_Timers.h ZComDef.h
    ../../../../Components/osal/common/: OSAL.c OSAL_Clock.c OSAL_Memory.c OSAL_PwrMgr.c OSAL_Timers.c
    ../../../../Components/osal/mcu/cc2530/: OSAL_Nv.c
  group Profile
    ../../../../Components/stack/af/: AF.c AF.h
    ../../../../Components/stack/sapi/: sapi.c
    ../../../../COMPONENTS/stack/sapi/: sapi.h
    ../../../../Components/stack/zcl/: zcl.c zcl.h zcl_key_establish.c zcl_key_establish.h
  group Security
    ../../../../COMPONENTS/stack/sec/: eccapi.h
    ../../../../Components/stack/sec/: ssp.h ssp_hash.h
  group Services
    ../../../../Components/services/saddr/: saddr.c saddr.h
  group Tools
    ../../Tools/CC2530DB/: f8w2530.xcl f8wConfig.cfg f8wZCL.cfg znp.cfg
  group ZDO
    ../../../../Components/stack/zdo/: ZDApp.c ZDApp.h ZDConfig.c ZDConfig.h ZDNwkMgr.c ZDNwkMgr.h ZDObject.c ZDObject.h ZDProfile.c ZDProfile.h ZDSecMgr.c ZDSecMgr.h
  group ZMac
    ../../../../Components/zmac/f8w/: zmac.c zmac_cb.c zmac_internal.h
    ../../../../Components/zmac/: ZMAC.h
  group ZMain
    ../../ZMain/TI2530ZNP/: chipcon_cstartup.s51 OnBoard.c OnBoard.h ZMain.c
